# Keil uVision project TrustZoneDisabled.uvprojx, settings and files
target TrustZoneDisabled (6210000::V6.21::ARMCLANG)
  device: STM32U366RETxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.2.0-A02
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=96000000,EXTERNALSAI1_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32U366xx
  c include: ../Inc;../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x10000
  scatter file: .\stm32u366xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32u366xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_ll_exti.c stm32u3xx_ll_utils.c stm32u3xx_ll_gpio.c stm32u3xx_ll_icache.c stm32u3xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
software components: CMSIS:CORE 6.1.0
