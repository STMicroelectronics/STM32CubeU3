# Keil uVision project TrustZoneEnabled_S.uvprojx, settings and files
target TrustZoneEnabled_S (6220000::V6.22::ARMCLANG)
  device: STM32U366RETxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.2.0-A01
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: TrustZoneEnabled_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U366xx
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x10000
  scatter file: TrustZoneEnabled_S\TrustZoneEnabled_S.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32u366xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_cortex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_icache.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32u3xx_s.c
software components: CMSIS:CORE 6.1.0
