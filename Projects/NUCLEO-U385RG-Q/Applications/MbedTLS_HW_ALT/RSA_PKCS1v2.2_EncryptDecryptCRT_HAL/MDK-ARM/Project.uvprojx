# Keil uVision project Project.uvprojx, settings and files
target TrustZoneDisabled_RSA_PKCS1v2.2_EncryptDecryptCRT_HAL (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U385xx,USE_HAL_DRIVER,USE_FULL_ASSERT,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MBEDTLS_USER_CONFIG_FILE=<mbedtls_alt_config.h>,USE_HAL_HASH_SUSPEND_RESUME=1
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns;../../../../../../Middlewares/Third_Party/mbedtls/include;../../../../../../Middlewares/Third_Party/mbedtls/include/mbedtls;../../../../../../Middlewares/Third_Party/mbedtls/include/psa;../../../../../../Middlewares/Third_Party/mbedtls/library;../../../../../../Drivers/BSP/STM32U3xx_Nucleo
  library: MicroLIB
  group Application/User
    ../Src/: stm32u3xx_it.c stm32u3xx_hal_msp.c main.c
  group Doc
    ../: README.md
  group Middlewares/ST/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: entropy_hardware_alt.c aes_alt.c rsa_alt.c sha256_alt.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: psa_crypto_hash.c psa_crypto_rsa.c aes.c psa_crypto.c psa_crypto_cipher.c psa_crypto_mac.c psa_crypto_client.c psa_crypto_slot_management.c psa_crypto_driver_wrappers_no_static.c psa_util.c asn1parse.c asn1write.c pkparse.c pk.c pk_wrap.c pkwrite.c rsa.c rsa_alt_helpers.c bignum.c bignum_core.c oid.c md.c platform_util.c sha256.c cipher.c cipher_wrap.c ctr_drbg.c entropy.c platform.c constant_time.c psa_crypto_random.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_pka.c stm32u3xx_hal_hash.c stm32u3xx_hal_rng.c stm32u3xx_hal_rng_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_cryp.c stm32u3xx_hal_cryp_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_icache.c
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Example/MDK-ARM
    ./: startup_stm32u385xx.s
software components: CMSIS:CORE 4.3.0
