# Keil uVision project Project.uvprojx, settings and files
target TrustZoneDisabled_Initial_Attestation_KWE (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U385xx,USE_HAL_DRIVER,USE_FULL_ASSERT,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MBEDTLS_USER_CONFIG_FILE=<mbedtls_alt_config.h>
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns;../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/core;../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/interface;../../../../../../Middlewares/Third_Party/mbedtls/include;../../../../../../Middlewares/Third_Party/mbedtls/include/mbedtls;../../../../../../Middlewares/Third_Party/mbedtls/include/psa;../../../../../../Middlewares/Third_Party/mbedtls/library;../../../../../../Utilities/Certificates;../../../../../../Drivers/BSP/STM32U3xx_Nucleo
  library: MicroLIB
  group Application/User
    ../Src/: stm32u3xx_it.c stm32u3xx_hal_msp.c storage_interface.c main.c
  group Doc
    ../: README.md
  group Utilities/Certificates
    ../../../../../../Utilities/Certificates/: stm32_cert.c
  group Middlewares/ST/mbedtls_key_wrap_engine
    ../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/core/: kwe_core.c
    ../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/interface/: kwe_psa_driver_interface.c kwe_psa_driver_key_management.c
  group Middlewares/ST/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: entropy_hardware_alt.c aes_alt.c psa_its_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c asn1parse.c asn1write.c cipher.c cipher_wrap.c md.c base64.c sha256.c ctr_drbg.c entropy.c bignum.c bignum_core.c constant_time.c ecp.c ecp_curves.c ecdsa.c hmac_drbg.c pem.c platform.c platform_util.c psa_crypto.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c psa_crypto_random.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_ccb.c stm32u3xx_hal_cortex.c stm32u3xx_hal_cryp.c stm32u3xx_hal_cryp_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_pka.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_rng.c stm32u3xx_hal_rng_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_icache.c
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Example/MDK-ARM
    ./: startup_stm32u385xx.s
software components: CMSIS:CORE 4.3.0
