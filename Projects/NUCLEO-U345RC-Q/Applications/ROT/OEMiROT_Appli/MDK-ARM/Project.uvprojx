# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U345RC-Q_OEMiROT_Appli (6210000::V6.21::ARMCLANG)
  device: STM32U345RCTx STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.5.0-A01
  cpu: IRAM(0x20000000,0x00004000) IRAM2(0x20004000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: NUCLEO-U345RC-Q_OEMiROT_Appli
  AfterMake: fromelf "#L" --bincombined --output="$L\..\..\..\Binary\oemirot_tz_s_app.bin"
  AfterMake: .\postbuild.bat "secure"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U345xx,USE_HAL_DRIVER
  c include: ../Inc;../Secure_nsclib;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include;..\..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x10000
  scatter file: .\stm32U345xx_flash_s.sct
  link misc: --predefine=-I..\Secure_nsclib
--predefine=-DSTM32U345xx
--import_cmse_lib_out=.\..\Secure_nsclib\secure_nsclib.o
  group Doc
    ../../: README.md
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Application/User
    ../Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c startup_stm32u3xx.c stm32u3xx_hal_msp.c stm32u3xx_it.c ymodem.c s_data.c
software components: CMSIS:CORE 5.6.0
