<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Target_ResetPattern_WakeUpFromStandBy.ewp</path>
  </project>
  <batchBuild />
</workspace>
