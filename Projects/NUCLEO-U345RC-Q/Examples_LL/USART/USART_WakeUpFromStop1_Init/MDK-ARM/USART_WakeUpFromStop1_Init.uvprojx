# Keil uVision project USART_WakeUpFromStop1_Init.uvprojx, settings and files
target USART_WakeUpFromStop1_Init (6140001::V6.14.1::ARMCLANG)
  device: STM32U345RCTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x08000000-0x803FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: USART_WakeUpFromStop1_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNALSAI1_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32U345xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include
  scatter file: stm32u345xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32u345xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_ll_exti.c stm32u3xx_ll_utils.c stm32u3xx_ll_gpio.c stm32u3xx_ll_icache.c stm32u3xx_ll_pwr.c stm32u3xx_ll_usart.c stm32u3xx_ll_rcc.c stm32u3xx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
software components: CMSIS:CORE 5.6.0
