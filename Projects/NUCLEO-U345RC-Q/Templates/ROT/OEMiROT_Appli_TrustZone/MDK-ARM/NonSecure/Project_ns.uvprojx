# Keil uVision project Project_ns.uvprojx, settings and files
target Templates_OEMiROT_Appli_TrustZone (6210000::V6.21::ARMCLANG)
  device: STM32U345RCTx STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-A01
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project_ns +hex
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\..\Binary\oemirot_tz_ns_app.bin"
  AfterMake: ..\postbuild.bat "nonsecure"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U345xx,USE_HAL_DRIVER
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32U345xx_flash_ns.sct
  link misc: --predefine=-DSTM32U345xx
--predefine=-I.\..\..\Secure_nsclib\
../../Secure_nsclib/secure_nsclib.o
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Application/User
    ../../NonSecure/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
    ../: startup_stm32U345xx.s
