# Keil uVision project TrustZoneDisabled.uvprojx, settings and files
target TrustZoneDisabled (6210000::V6.21::ARMCLANG)
  device: STM32U345RCTxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0-RC2
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x08000000-0x803FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U345xx
  c include: ../Inc;../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32u345xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_cortex.c stm32u3xx_hal_icache.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
software components: CMSIS:CORE 5.6.0
