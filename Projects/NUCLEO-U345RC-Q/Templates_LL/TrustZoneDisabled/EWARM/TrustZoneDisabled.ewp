# IAR project TrustZoneDisabled.ewp, settings and files
configuration TrustZoneDisabled (ARM, debug)
  General.OGChipSelectEditMenu: STM32U345RC ST STM32U345RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=16000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=96000000; EXTERNALSAI1_CLOCK_VALUE=48000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; STM32U345xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneDisabled.hex
  ILINK.IlinkOutputFile: TrustZoneDisabled.out
  ILINK.IlinkIcfFile: stm32u345xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u345xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_ll_exti.c stm32u3xx_ll_utils.c stm32u3xx_ll_gpio.c stm32u3xx_ll_icache.c stm32u3xx_ll_pwr.c
