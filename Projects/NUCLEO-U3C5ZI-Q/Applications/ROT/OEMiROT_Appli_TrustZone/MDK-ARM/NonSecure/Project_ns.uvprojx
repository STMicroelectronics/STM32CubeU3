# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-U3C5ZI-Q_OEMiROT_Appli_TrustZone_NS (6210000::V6.21::ARMCLANG)
  device: STM32U3C5ZITx STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.5.0-A01
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\..\Binary\oemirot_tz_ns_app.bin"
  AfterMake: ..\postbuild.bat "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U3C5xx,USE_HAL_DRIVER,BL2
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../NonSecure/Inc;../../Secure_nsclib;..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver;..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext;..\..\..\OEMiROT_Boot\Inc
  library: MicroLIB
  scatter file: stm32u3c5xx_flash_ns.sct
  link misc: --predefine=-DSTM32U3C5xx
--predefine=-I.\..\..\Secure_nsclib\
../../Secure_nsclib/secure_nsclib.o
  group Doc
    ../../: README.md
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32u3xx_ns.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c low_level_device.c com.c common.c stm32u3xx_it.c main.c fw_update_app.c ns_data.c startup_stm32u3xx.c ymodem.c
