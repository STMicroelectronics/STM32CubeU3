# IAR project Project_s.ewp, settings and files
configuration NUCLEO-U3C5ZI-Q_OEMiROT_Appli_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5ZI ST STM32U3C5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U3C5xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\Secure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Binary\oemirot_tz_s_app.bin
  prebuild: prebuild_s.cmd "$PROJ_DIR$" "STM32U3C5xx"
  postbuild: cmd /C "cmd /C ..\postbuild.bat "secure""
  ILINK.IlinkOutputFile: NUCLEO-U3C5ZI-Q.out
  ILINK.IlinkIcfFile: stm32u3c5xx_flash_s.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Secure/Src/: low_level_device.c low_level_flash.c main.c secure_nsc.c startup_stm32u3xx.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32u3xx_s.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c
