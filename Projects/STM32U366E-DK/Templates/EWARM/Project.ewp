# IAR project Project.ewp, settings and files
configuration STM32U366E-DK_Templates_HAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U366VE ST STM32U366VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U366xx; USE_HAL_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Inc; ../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../Drivers/CMSIS/Include; ../../../../Drivers/BSP/STM32U366E-DK; ../../../../Drivers/BSP/STM32U366E-DK/sht40
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u366xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U366E-DK
    ../../../../Drivers/BSP/STM32U366E-DK/sht40/: sht40.c sht40_reg.c
    ../../../../Drivers/BSP/STM32U366E-DK/: stm32u366e_discovery.c stm32u366e_discovery_bus.c stm32u366e_discovery_combo_sensor.c stm32u366e_discovery_glass_lcd.c
  group Drivers/CMSIS
    ./: startup_stm32u366xx.s
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_gpio.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_lcd.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c
