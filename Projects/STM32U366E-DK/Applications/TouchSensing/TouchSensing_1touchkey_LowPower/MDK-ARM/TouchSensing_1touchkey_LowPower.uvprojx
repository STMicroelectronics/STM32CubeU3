# Keil uVision project TouchSensing_1touchkey_LowPower.uvprojx, settings and files
target TouchSensing_1touchkey_LowPower (6210000::V6.21::ARMCLANG)
  device: STM32U366VETxQ STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.5.0-A01
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x20020000-0x2002FFFF) IROM(0x08000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TouchSensing_1touchkey_LowPower +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U366xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc;../../../../../../Drivers/BSP/STM32U366E-DK;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x10000
  scatter file: stm32u366xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32u366xx.s
  group Application/User
    ../Src/: main.c touchsensing.c tsl_user.c stmCriticalSection.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_cortex.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_tsc.c stm32u3xx_hal_adc.c stm32u3xx_hal_lcd.c stm32u3xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Middlewares/TouchSensing
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq_tsc.c tsl_globals.c tsl_touchkey.c tsl_acq.c tsl_dxs.c tsl_linrot.c tsl_ecs.c tsl_object.c tsl_time.c tsl_filter.c
  group Drivers/BSP/STM32U366E-DK
    ../../../../../../Drivers/BSP/STM32U366E-DK/: stm32u366e_discovery.c stm32u366e_discovery_glass_lcd.c
software components: CMSIS:CORE 5.6.0
