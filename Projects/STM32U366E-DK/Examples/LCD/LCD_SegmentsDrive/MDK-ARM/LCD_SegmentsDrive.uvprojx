# Keil uVision project LCD_SegmentsDrive.uvprojx, settings and files
target LCD_SegmentsDrive (6210000::V6.21::ARMCLANG)
  device: STM32U366VETx STMicroelectronics
  pack: Keil.STM32U3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) XRAM(0x20020000,0x00010000) XRAM2(0x30020000,0x00010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: LCD_SegmentsDrive +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U366xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32U366E-DK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT6: RAM 0x20020000 size 0x10000
  memory RVCT7: RAM 0x30020000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32u366xx.s
  group Application/User
    ../Src/: main.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32U366E-DK
    ../../../../../../Drivers/BSP/STM32U366E-DK/: stm32u366e_discovery_glass_lcd.c stm32u366e_discovery.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_lcd.c stm32u3xx_hal_cortex.c stm32u3xx_hal_icache.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
software components: CMSIS:CORE 5.6.0
