# IAR project STM32U366E_DK_Demo.ewp, settings and files
configuration STM32U366E_DK_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32U366VE ST STM32U366VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U366xx; USE_STM32U366E_DISCO; USE_VCP_CONNECTION
  ICCARM.CCDiagSuppress: Pe1422, Pe026
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/STM32U366E-DK; ../../../../../Drivers/BSP/STM32U366E-DK/sht40; ../../../../../Drivers/BSP/Components/Common; ../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc; ..\..\main_app
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32U366E_DK_Demo.hex
  ILINK.IlinkOutputFile: STM32U366E_DK_Demo.out
  ILINK.IlinkIcfFile: stm32u366xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u366xx.s
  group Application/Modules/AppMain
    ../../main_app/: app_main.c stmCriticalSection.c touchsensing.c tsl_user.c
  group Application/User
    ../Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/sht40
    ../../../../../Drivers/BSP/STM32U366E-DK/sht40/: sht40.c sht40_reg.c
  group Drivers/BSP/STM32U366E-DK
    ../../../../../Drivers/BSP/STM32U366E-DK/: stm32u366e_discovery.c stm32u366e_discovery_bus.c stm32u366e_discovery_combo_sensor.c stm32u366e_discovery_glass_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_lcd.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_spi.c stm32u3xx_hal_spi_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_tsc.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_usart.c stm32u3xx_hal_usart_ex.c stm32u3xx_ll_adc.c stm32u3xx_ll_i2c.c
  group Middlewares/TouchSensing
    ../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq.c tsl_acq_tsc.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_touchkey.c
